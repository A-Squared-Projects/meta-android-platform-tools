# Fetch AOSP projects straight from their git servers, one SRC_URI entry per
# project, each checked out at its AOSP path under ${S} and pinned to the
# commit that AOSP_TAG names.
#
#   AOSP_TAG = "android-17.0.0_r1"
#   AOSP_PROJECTS = "packages/modules/adb system/core ..."
#   inherit aosp-projects
#
# The pins live in ${THISDIR}/${BPN}-aosp-srcrevs.inc, which the recipe
# requires. After changing AOSP_TAG or AOSP_PROJECTS, regenerate it with
#
#   bitbake -c update_aosp_srcrevs <recipe>

AOSP_GIT_URI ??= "git://android.googlesource.com/platform"
AOSP_TAG ??= ""
AOSP_PROJECTS ??= ""
# The directory under ${UNPACKDIR} that holds the tree, which S should name.
AOSP_TREE ??= "${BP}"

BB_GIT_SHALLOW ?= "1"

def aosp_srcrev_name(project):
    return project.replace('/', '_')

def aosp_src_uri(d):
    uri = d.getVar('AOSP_GIT_URI')
    tag = d.getVar('AOSP_TAG')
    tree = d.getVar('AOSP_TREE')
    return ' '.join(
        '%s/%s;protocol=https;nobranch=1;tag=%s;name=%s;destsuffix=%s/%s'
        % (uri, p, tag, aosp_srcrev_name(p), tree, p)
        for p in d.getVar('AOSP_PROJECTS').split())

SRC_URI += "${@aosp_src_uri(d)}"
SRCREV_FORMAT ?= "${@aosp_srcrev_name(d.getVar('AOSP_PROJECTS').split()[0])}"

addtask do_update_aosp_srcrevs
do_update_aosp_srcrevs[nostamp] = "1"
do_update_aosp_srcrevs[network] = "1"
do_update_aosp_srcrevs[doc] = "Pin each of AOSP_PROJECTS to AOSP_TAG in ${THISDIR}/${BPN}-aosp-srcrevs.inc"

RECIPE_UPGRADE_EXTRA_TASKS += "do_update_aosp_srcrevs"

python do_update_aosp_srcrevs() {
    import subprocess

    uri = d.getVar('AOSP_GIT_URI').replace('git://', 'https://', 1)
    tag = d.getVar('AOSP_TAG')
    if not tag:
        bb.fatal('AOSP_TAG is not set')

    lines = ['# Generated by bitbake -c update_aosp_srcrevs %s; do not edit.' % d.getVar('PN'),
             'AOSP_SRCREVS_TAG = "%s"' % tag]
    for project in d.getVar('AOSP_PROJECTS').split():
        ref = 'refs/tags/%s^{}' % tag
        out = subprocess.check_output(['git', 'ls-remote', '%s/%s' % (uri, project), ref],
                                      text=True).split()
        if len(out) != 2 or out[1] != ref or len(out[0]) != 40:
            bb.fatal('%s: no %s at %s/%s' % (project, ref, uri, project))
        lines.append('SRCREV_%s = "%s"' % (aosp_srcrev_name(project), out[0]))

    target = d.expand('${THISDIR}/${BPN}-aosp-srcrevs.inc')
    with open(target, 'w') as f:
        f.write('\n'.join(lines) + '\n')
    bb.plain('Wrote %s: %d projects at %s' % (target, len(lines) - 2, tag))
}

# A stale include pins commits from another tag. Checked when fetching rather
# than at parse, so update_aosp_srcrevs can still run to fix it.
python aosp_check_srcrevs() {
    pinned = d.getVar('AOSP_SRCREVS_TAG')
    if pinned != d.getVar('AOSP_TAG'):
        bb.fatal('%s-aosp-srcrevs.inc pins %s, not AOSP_TAG %s: run bitbake -c update_aosp_srcrevs %s'
                 % (d.getVar('BPN'), pinned, d.getVar('AOSP_TAG'), d.getVar('PN')))
}
do_fetch[prefuncs] += "aosp_check_srcrevs"
